options:
  parameters:
    generate_options: qt_gui
    id: untitled
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '23040000'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: zeromq_rep_sink_0
  id: zeromq_rep_sink
  parameters:
    address: tcp://172.30.0.201:2001
    comment: UE1_DL
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_rep_sink_0_0
  id: zeromq_rep_sink
  parameters:
    address: tcp://172.30.0.201:2002
    comment: UE2_DL
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_rep_sink_0_1
  id: zeromq_rep_sink
  parameters:
    address: tcp://172.30.0.201:2003
    comment: UE3_DL
    timeout: '100'
    type: complex
  states: {state: disabled}
- name: zeromq_rep_sink_0_1_0
  id: zeromq_rep_sink
  parameters:
    address: tcp://172.30.0.201:2000
    comment: gNB_UL
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_req_source_0
  id: zeromq_req_source
  parameters:
    address: tcp://172.30.0.100:2000
    comment: gNB_DL
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_req_source_0_0
  id: zeromq_req_source
  parameters:
    address: tcp://172.30.0.101:2000
    comment: UE1_UL
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_req_source_0_0_0
  id: zeromq_req_source
  parameters:
    address: tcp://172.30.0.102:2000
    comment: UE2_UL
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_req_source_0_0_1
  id: zeromq_req_source
  parameters:
    address: tcp://172.30.0.103:2000
    comment: UE3_UL
    timeout: '100'
    type: complex
  states: {state: disabled}

connections:
- [blocks_add_xx_0, '0', zeromq_rep_sink_0_1_0, '0']
- [blocks_throttle_0, '0', zeromq_rep_sink_0, '0']
- [blocks_throttle_0, '0', zeromq_rep_sink_0_0, '0']
- [blocks_throttle_0, '0', zeromq_rep_sink_0_1, '0']
- [zeromq_req_source_0, '0', blocks_throttle_0, '0']
- [zeromq_req_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [zeromq_req_source_0_0, '0', blocks_add_xx_0, '0']
- [zeromq_req_source_0_0_0, '0', blocks_add_xx_0, '1']

metadata:
  file_format: 1
